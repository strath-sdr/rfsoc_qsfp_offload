options:
  parameters:
    author: Marsiau
    generate_options: qt_gui
    id: udp2fosphor
    output_language: python
  states: {}

blocks:
- name: center_f
  id: variable
  parameters:
    value: 1228.8e6
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2457.6*1e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_f
    freq_span: samp_rate
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', fosphor_qt_sink_c_0, '0']
- [network_udp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
